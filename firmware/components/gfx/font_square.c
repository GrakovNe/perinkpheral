/*
 * SPDX-License-Identifier: MIT
 * Copyright (c) 2026 GrakovNe
 *
 * The square font: every glyph
 * is a square built on a grid of three strokes and two gaps, in both
 * directions (27 px = 5 + 6 + 5 + 6 + 5). No ascenders, no descenders:
 * lower case is drawn in the same square. Straight bars on the grid
 * plus a few diagonals (the leg of r, N, K, V, X, Z).
 *
 * A glyph is five rows of five cells; even cells are strokes, odd cells
 * are gaps. '#' fills a cell; a bar across a gap cell is what makes a
 * continuous stroke. Diagonals run between cell centres.
 */
#include "font_square.h"

static const int8_t d_none[] = { -1 };
#define NONE d_none

static const int8_t d_r[]  = { 2, 2, 4, 4, -1 };                 /* leg from the middle to bottom right */
static const int8_t d_n[]  = { 0, 0, 4, 4, -1 };
static const int8_t d_k[]  = { 0, 2, 4, 0, 0, 2, 4, 4, -1 };
static const int8_t d_v[]  = { 0, 0, 2, 4, 4, 0, 2, 4, -1 };
static const int8_t d_x[]  = { 0, 0, 4, 4, 4, 0, 0, 4, -1 };
static const int8_t d_z[]  = { 4, 0, 0, 4, -1 };
static const int8_t d_q[]  = { 2, 2, 4, 4, -1 };
static const int8_t d_sl[] = { 4, 0, 0, 4, -1 };
static const int8_t d_bs[] = { 0, 0, 4, 4, -1 };

static const sq_glyph_t lower[26] = {
    { { "#####", "....#", "#####", "#...#", "#####" }, NONE }, /* a */
    { { "#....", "#....", "#####", "#...#", "#####" }, NONE }, /* b */
    { { "#####", "#....", "#....", "#....", "#####" }, NONE }, /* c */
    { { "....#", "....#", "#####", "#...#", "#####" }, NONE }, /* d */
    { { "#####", "#...#", "###..", "#....", "#####" }, NONE }, /* e, as in "error" */
    { { "#####", "#....", "###..", "#....", "#...." }, NONE }, /* f */
    { { "#####", "#....", "#.###", "#...#", "#####" }, NONE }, /* g */
    { { "#....", "#....", "#####", "#...#", "#...#" }, NONE }, /* h */
    { { "..#..", ".....", "..#..", "..#..", "..#.." }, NONE }, /* i */
    { { "....#", ".....", "....#", "....#", "#####" }, NONE }, /* j */
    { { "#....", "#....", "#....", "#....", "#...." }, d_k }, /* k */
    { { "..#..", "..#..", "..#..", "..#..", "..#.." }, NONE }, /* l */
    { { "#####", "#.#.#", "#.#.#", "#.#.#", "#.#.#" }, NONE }, /* m */
    { { "#####", "#...#", "#...#", "#...#", "#...#" }, NONE }, /* n */
    { { "#####", "#...#", "#...#", "#...#", "#####" }, NONE }, /* o */
    { { "#####", "#...#", "#####", "#....", "#...." }, NONE }, /* p */
    { { "#####", "#...#", "#####", "....#", "....#" }, NONE }, /* q */
    { { "#####", "#...#", "#####", "#....", "#...." }, d_r }, /* r, as in "error" */
    { { "#####", "#....", "#####", "....#", "#####" }, NONE }, /* s */
    { { "..#..", "..#..", "#####", "..#..", "..###" }, NONE }, /* t */
    { { "#...#", "#...#", "#...#", "#...#", "#####" }, NONE }, /* u */
    { { ".....", ".....", ".....", ".....", "....." }, d_v }, /* v */
    { { "#...#", "#...#", "#.#.#", "#.#.#", "#####" }, NONE }, /* w */
    { { ".....", ".....", ".....", ".....", "....." }, d_x }, /* x */
    { { "#...#", "#...#", "#####", "....#", "#####" }, NONE }, /* y */
    { { "#####", ".....", ".....", ".....", "#####" }, d_z }, /* z */
};

static const sq_glyph_t upper[26] = {
    { { "#####", "#...#", "#####", "#...#", "#...#" }, NONE }, /* A */
    { { "####.", "#...#", "####.", "#...#", "####." }, NONE }, /* B */
    { { "#####", "#....", "#....", "#....", "#####" }, NONE }, /* C */
    { { "####.", "#...#", "#...#", "#...#", "####." }, NONE }, /* D */
    { { "#####", "#....", "#####", "#....", "#####" }, NONE }, /* E */
    { { "#####", "#....", "#####", "#....", "#...." }, NONE }, /* F */
    { { "#####", "#....", "#.###", "#...#", "#####" }, NONE }, /* G */
    { { "#...#", "#...#", "#####", "#...#", "#...#" }, NONE }, /* H */
    { { "..#..", "..#..", "..#..", "..#..", "..#.." }, NONE }, /* I */
    { { "....#", "....#", "....#", "#...#", "#####" }, NONE }, /* J */
    { { "#....", "#....", "#....", "#....", "#...." }, d_k }, /* K */
    { { "#....", "#....", "#....", "#....", "#####" }, NONE }, /* L */
    { { "#####", "#.#.#", "#.#.#", "#...#", "#...#" }, NONE }, /* M */
    { { "#...#", "#...#", "#...#", "#...#", "#...#" }, d_n }, /* N */
    { { "#####", "#...#", "#...#", "#...#", "#####" }, NONE }, /* O */
    { { "#####", "#...#", "#####", "#....", "#...." }, NONE }, /* P */
    { { "#####", "#...#", "#...#", "#...#", "#####" }, d_q }, /* Q */
    { { "#####", "#...#", "#####", "#....", "#...." }, d_r }, /* R */
    { { "#####", "#....", "#####", "....#", "#####" }, NONE }, /* S */
    { { "#####", "..#..", "..#..", "..#..", "..#.." }, NONE }, /* T */
    { { "#...#", "#...#", "#...#", "#...#", "#####" }, NONE }, /* U */
    { { ".....", ".....", ".....", ".....", "....." }, d_v }, /* V */
    { { "#...#", "#...#", "#.#.#", "#.#.#", "#####" }, NONE }, /* W */
    { { ".....", ".....", ".....", ".....", "....." }, d_x }, /* X */
    { { "#...#", "#...#", "#####", "..#..", "..#.." }, NONE }, /* Y */
    { { "#####", ".....", ".....", ".....", "#####" }, d_z }, /* Z */
};

static const sq_glyph_t digit[10] = {
    { { "#####", "#...#", "#...#", "#...#", "#####" }, NONE }, /* 0 */
    { { "...##", "....#", "....#", "....#", "....#" }, NONE }, /* 1: flag one stroke and a gap wide */
    { { "#####", "....#", "#####", "#....", "#####" }, NONE }, /* 2 */
    { { "#####", "....#", "#####", "....#", "#####" }, NONE }, /* 3 */
    { { "#...#", "#...#", "#####", "....#", "....#" }, NONE }, /* 4 */
    { { "#####", "#....", "#####", "....#", "#####" }, NONE }, /* 5 */
    { { "#####", "#....", "#####", "#...#", "#####" }, NONE }, /* 6 */
    { { "#####", "....#", "....#", "....#", "....#" }, NONE }, /* 7 */
    { { "#####", "#...#", "#####", "#...#", "#####" }, NONE }, /* 8 */
    { { "#####", "#...#", "#####", "....#", "#####" }, NONE }, /* 9 */
};

static const sq_glyph_t g_space    = { { ".....", ".....", ".....", ".....", "....." }, NONE };
static const sq_glyph_t g_dash     = { { ".....", ".....", "###..", ".....", "....." }, NONE };
static const sq_glyph_t g_dot      = { { ".....", ".....", ".....", ".....", "#...." }, NONE };
static const sq_glyph_t g_comma    = { { ".....", ".....", ".....", "#....", "#...." }, NONE };
static const sq_glyph_t g_colon    = { { ".....", "#....", ".....", "#....", "....." }, NONE };
static const sq_glyph_t g_lparen   = { { "###..", "#....", "#....", "#....", "###.." }, NONE };
static const sq_glyph_t g_rparen   = { { "..###", "....#", "....#", "....#", "..###" }, NONE };
static const sq_glyph_t g_slash    = { { ".....", ".....", ".....", ".....", "....." }, d_sl };
static const sq_glyph_t g_bslash   = { { ".....", ".....", ".....", ".....", "....." }, d_bs };
static const sq_glyph_t g_plus     = { { ".....", "..#..", "#####", "..#..", "....." }, NONE };
static const sq_glyph_t g_percent  = { { "#....", ".....", ".....", ".....", "....#" }, d_sl };
static const sq_glyph_t g_question = { { "#####", "....#", "..###", ".....", "..#.." }, NONE };

const sq_glyph_t *gfx_font_square_glyph(uint32_t cp)
{
    if (cp >= 'a' && cp <= 'z') {
        return &lower[cp - 'a'];
    }
    if (cp >= 'A' && cp <= 'Z') {
        return &upper[cp - 'A'];
    }
    if (cp >= '0' && cp <= '9') {
        return &digit[cp - '0'];
    }
    switch (cp) {
    case ' ':  return &g_space;
    case '-':  return &g_dash;
    case '.':  return &g_dot;
    case ',':  return &g_comma;
    case ':':  return &g_colon;
    case '(':  return &g_lparen;
    case ')':  return &g_rparen;
    case '/':  return &g_slash;
    case '\\': return &g_bslash;
    case '+':  return &g_plus;
    case '%':  return &g_percent;
    default:   return &g_question;
    }
}
